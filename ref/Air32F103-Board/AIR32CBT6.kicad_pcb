# Repository pengwon/air32f103-mini

File README.md:

# air32f103-mini
AIR32F103 minimal dev board

## KiCad design ref/Air32F103-Board/AIR32CBT6.kicad_pcb

Parts:
C1, C2, C3, C4: 12p; C_0402_1005Metric
C7: 1uF; C_0402_1005Metric
C8, C10: 0.1uF; C_0402_1005Metric
C9: 10uF; C_0402_1005Metric
C11, C12: 0.1uf; C_0402_1005Metric
D1, D2, D3: BDFN2C051V; DFN1006-2L
D4, D5, D6: LED; LED_0603_1608Metric
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J12, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24, J25, J26, J27, J28, J29, J30, J31, J32, J33, J34, J35, J36, J37, J38, J39, J40: Conn_01x01; TP-1.6-p1.0-2
J41: DAPLink-port
JP1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
R1, R3, R4, R7, R8, R9: 512; R_0402_1005Metric
R2, R10: 10K; R_0402_1005Metric
R5: 100R; R_0402_1005Metric
R6: 1.5k; R_0402_1005Metric
SW1, SW2: SW_Push; SW_SPST_PTS810
U1: LQFP-48_7x7mm_P0.5mm
U2: SGM2019-3.3YN5G/TR; SOT-23-5
Y1: 32.768K; Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering
Y2: 8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C9.1, C10.1, C11.1, C12.1, J9.1, J17.1, J35.1, J41.2, J41.10, R2.1, R6.1, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.5 (OUT); also elsewhere on the board
/BOOT: R10.2, SW1.2, U1.44 (BOOT0); also elsewhere on the board
/PA0: J5.1, U1.10 (PA0)
/PA1: J6.1, U1.11 (PA1)
/PA2: J11.1, U1.12 (PA2)
/PA3: J12.1, U1.13 (PA3)
/PA4: J13.1, U1.14 (PA4)
/PA5: J16.1, U1.15 (PA5)
/PA6: J14.1, U1.16 (PA6)
/PA7: J15.1, U1.17 (PA7)
/PA8: J26.1, U1.29 (PA8)
/PA9: J30.1, U1.30 (PA9)
/PA10: J31.1, U1.31 (PA10)
/PA11: D3.1 (A1), JP1.A7 (D-), JP1.B7 (D-), U1.32 (PA11)
/PA12: D2.1 (A1), JP1.A6 (D+), JP1.B6 (D+), R6.2, U1.33 (PA12)
/PA15: J32.1, U1.38 (PA15)
/PB0: J19.1, J41.1, U1.18 (PB0)
/PB1: J20.1, U1.19 (PB1)
/PB2: R9.2, U1.20 (PB2)
/PB3: J33.1, U1.39 (PB3)
/PB4: J39.1, U1.40 (PB4)
/PB5: J40.1, U1.41 (PB5)
/PB6: J28.1, U1.42 (PB6)
/PB7: J27.1, U1.43 (PB7)
/PB8: J8.1, U1.45 (PB8)
/PB9: J7.1, U1.46 (PB9)
/PB10: R8.2, U1.21 (PB10)
/PB11: R7.2, U1.22 (PB11)
/PB12: J21.1, R5.1, U1.25 (PB12)
/PB13: J22.1, J41.4, U1.26 (PB13)
/PB14: J24.1, J41.3, R5.2, U1.27 (PB14)
/PB15: J25.1, U1.28 (PB15)
/PC13: J41.6, U1.2 (PC13)
/PC14: C3.1, J1.1, U1.3 (PC14), Y1.2
/PC15: C4.1, J2.1, U1.4 (PC15), Y1.1
/PWB: J37.1, R1.1, U2.3 (EN)
/RST: C8.2, J34.1, R2.2, SW2.2, U1.7 (NRST); also elsewhere on the board
/SWCLK: J41.9, U1.37 (PA14)
/SWDIO: J41.8, U1.34 (PA13)
GND: C1.2, C2.2, C3.2, C4.2, C7.2, C8.1, C9.2, C10.2, C11.2, C12.2, D1.2 (A2), D2.2 (A2), D3.2 (A2), D4.1 (K), D5.1 (K), D6.1 (K), J3.1, J10.1, J18.1, J23.1, J29.1, J36.1, J41.5, J41.7, JP1.A1 (GND), JP1.A12 (GND), JP1.B1 (GND), JP1.B12 (GND), JP1.S1 (SHIELD), R3.2, R4.2, R10.1, SW2.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.2 (GND), Y2.2, Y2.4; also elsewhere on the board
unnamed: C1.1, U1.5 (PD0), Y2.3
unnamed: C2.1, U1.6 (PD1), Y2.1
unnamed: D4.2 (A), R7.1
unnamed: D5.2 (A), R8.1
unnamed: D6.2 (A), R9.1
unnamed: JP1.A5 (CC1), R3.1
unnamed: JP1.B5 (CC2), R4.1
VBUS: C7.1, D1.1 (A1), J4.1, J38.1, JP1.A4 (VBUS), JP1.A9 (VBUS), JP1.B4 (VBUS), JP1.B9 (VBUS), R1.2, U2.1 (IN)

Notes on the sheet:
daplink需要用这个电阻

Board: 2 copper layers, 21.0 x 51.0 mm, 74 parts (0 on the bottom side), 48 nets.

Other parts of the board:
BOOT: SW_Push; SW_SPST_PTS810
RST: SW_Push; SW_SPST_PTS810

Their connections:
+3V3: BOOT.1; also elsewhere on the board
/BOOT: BOOT.2; also elsewhere on the board
/RST: RST.2; also elsewhere on the board
GND: RST.1; also elsewhere on the board

## Commit log

2022-10-05 initial commit
    new file: .gitignore
    new file: LICENSE
    new file: README.md
    new file: air32f103-mini.PrjPcb
    new file: ref/Air32F103-Board/AIR32CBT6.kicad_pcb
    new file: ref/Air32F103-Board/AIR32CBT6.kicad_pro
